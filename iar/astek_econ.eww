<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\astek_econ\astek_econ.hw2041.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\project\astek_econ\astek_econ.hw2331.ewp</path>
    </project>
    <batchBuild />
</workspace>

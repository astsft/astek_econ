# IAR project astek_econ.hw2331_rev3.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; WF70A2SZAGDNN0
  ICCARM.CCIncludePath2: ..\..\..\src\app\astek_econ; ..\..\..\src\app\astek_econ\config; ..\..\..\src\app\astek_econ\config\emwin; ..\..\..\src\app\astek_econ\gui\emwin; ..\..\..\src\app\astek_econ\hw\hw2331r2; ..\..\..\src\app\astek_econ\modbus; ..\..\..\src\app\common\; ..\..\..\src\bsp\hw2331_rev3; ..\..\..\src\bsp\hw2331_rev3\mt48lc1; ..\..\..\src\bsp\hw2331_rev3\stm32; ..\..\..\src\emwin\inc; ..\..\..\src\mcu\iar; ..\..\..\src\lib\arm\CMSIS\Core\Include; ..\..\..\src\lib\arm\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\src\lib\astsoft\modbus\src; ..\..\..\src\lib\FreeRTOS\cmsis_rtos; ..\..\..\src\lib\FreeRTOS\include; ..\..\..\src\lib\FreeRTOS\portable\iar\arm_cm7\r0p1; ..\..\..\src\lib\goodix\gt9xx; ..\..\..\src\lib\st\STemWin\inc; ..\..\..\src\lib\st\STM32F7xx_HAL_Driver\Inc; ..\..\..\src\app\astek_econ\dev\log; ..\..\..\src\lib\astsoft\econ; ..\..\..\src\app\astek_econ\hw; ..\..\..\src\app\astek_econ\version\Inc; ..\..\..\src\bsp\hw2331_rev3\asback; ..\..\..\src\app\astek_econ\hw\hw2331r2\external_flash; ..\..\..\src\bsp\hw2331_rev3\spi_flash\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\app\astek_econ\config
  OBJCOPY.OOCOutputFile: astek_econ.hw2331.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$ - $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: config\stm32f746xx_flash_wo_dtcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F746xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; WF70A2SZAGDNN0; NDEBUG
  ICCARM.PreInclude: ..\..\..\src\app\preconfig.h
  ICCARM.CCIncludePath2: ..\..\..\src\app\astek_econ; ..\..\..\src\app\astek_econ\config; ..\..\..\src\app\astek_econ\config\emwin; ..\..\..\src\app\astek_econ\gui\emwin; ..\..\..\src\app\astek_econ\hw\hw2331r2; ..\..\..\src\app\astek_econ\modbus; ..\..\..\src\app\common\; ..\..\..\src\bsp\hw2331_rev3; ..\..\..\src\bsp\hw2331_rev3\stm32; ..\..\..\src\emwin\inc; ..\..\..\src\mcu\iar; ..\..\..\src\lib\arm\CMSIS\Core\Include; ..\..\..\src\lib\arm\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\src\lib\astsoft\modbus\src; ..\..\..\src\lib\FreeRTOS\cmsis_rtos; ..\..\..\src\lib\FreeRTOS\include; ..\..\..\src\lib\FreeRTOS\portable\iar\arm_cm7\r0p1; ..\..\..\src\lib\goodix\gt9xx; ..\..\..\src\lib\st\STemWin\inc; ..\..\..\src\lib\st\STM32F7xx_HAL_Driver\Inc; ..\..\..\src\app\astek_econ\dev\log; ..\..\..\src\lib\astsoft\econ; ..\..\..\src\app\astek_econ\version\Inc; ..\..\..\src\app\astek_econ\hw; ..\..\..\src\bsp\hw2331_rev3\asback; ..\..\..\src\bsp\hw2331_rev3\spi_flash\Inc; ..\..\..\src\app\astek_econ\hw\hw2331r2\external_flash; ..\..\..\..\astek_4021\src\app\astek_4021\hw\hw2331r2\eth; ..\..\..\..\astek_4021\src\bsp\hw2331r2\w5500; ..\..\..\..\astek_4021\src\bsp\hw2331r2\w5500\ioLibrary_Driver\Ethernet; ..\..\..\..\astek_4021\src\bsp\hw2331r2\w5500\ioLibrary_Driver\Ethernet\W5500; ..\..\..\..\astek_4021\src\bsp\hw2331r2\w5500\ioLibrary_Driver\Internet\httpServer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: ..\..\..\hex\astek_econ\2331_rev3\$PROJ_FNAME$.hex
  prebuild: ..\..\..\src\app\astek_econ\version\genversion_commit.bat
  postbuild: ..\..\..\src\app\modify.bat
  ILINK.IlinkIcfFile: config\stm32f746xx_flash.icf
  group app/astek_econ
    ../../../src/app/astek_econ/: main.c task_hmi.c task_ibus.c task_m2m.c task_net.c task_start.c
  group app/astek_econ/config/emwin
    ../../../src/app/astek_econ/config/emwin/: GUIConf.c LCDConf.c
  group app/astek_econ/config/emwin/os
    ../../../src/app/astek_econ/config/emwin/os/: GUI_X.c GUI_X_FreeRTOS.c
  group app/astek_econ/dev
    ../../../src/app/astek_econ/dev/: dev.c
  group app/astek_econ/dev/cl420
    ../../../src/app/astek_econ/dev/cl420/: cl420.c
  group app/astek_econ/dev/log
    ../../../src/app/astek_econ/dev/log/: log.c
  group app/astek_econ/dev/meas
    ../../../src/app/astek_econ/dev/meas/: meas.c
  group app/astek_econ/gui/emwin
    ../../../src/app/astek_econ/gui/emwin/: emwin_init_listwheel.c emwin_set_defaults.c
  group app/astek_econ/gui/emwin/font
    ../../../src/app/astek_econ/gui/emwin/font/: tahoma150.c tahoma30.c tahoma40.c
  group app/astek_econ/gui/emwin/l10n
    ../../../src/app/astek_econ/gui/emwin/l10n/: l10n_str.c
  group app/astek_econ/gui/emwin/scr
    ../../../src/app/common/gui/emwin/res/: astek_logo_800x480_png.c
    ../../../src/app/astek_econ/gui/emwin/scr/: scr.c scr_init_text.c scr_init_text_label.c scr_init_text_value.c
  group app/astek_econ/gui/emwin/scr/800x480
    ../../../src/app/astek_econ/gui/emwin/scr/800x480/: scr_calibrate.c scr_calibrate_point.c scr_calibrate_restore.c scr_console.c scr_measure.c scr_setup.c scr_setup_calibrate.c scr_setup_calibrate_auto.c scr_setup_calibrate_auto_cycle.c scr_setup_calibrate_auto_launch.c scr_setup_calibrate_auto_purge.c scr_setup_measure.c scr_setup_measure_cl420.c scr_setup_measure_cl420_value.c scr_setup_measure_sensor.c scr_setup_service.c scr_setup_service_cloop.c scr_setup_service_cloop_cal.c scr_setup_service_cloop_cal_4_20mA.c scr_setup_service_cloop_channel.c scr_setup_service_cloop_diagnostic.c scr_setup_service_cloop_error_level.c scr_setup_service_diagnostics.c scr_setup_service_entry.c scr_setup_service_entry_error.c scr_setup_service_measure.c scr_setup_service_modbus.c scr_setup_service_network.c scr_setup_service_network_ip.c scr_setup_service_network_mac.c scr_setup_service_network_port.c scr_setup_service_relay.c scr_setup_service_relay_param.c scr_setup_service_relay_param_mode.c scr_setup_service_relay_param_state.c scr_setup_service_relay_param_threshold.c scr_setup_service_reset_password_entry.c scr_setup_service_reset_password_error.c scr_setup_service_reset_password_success.c scr_setup_service_reset_settings_entry.c scr_setup_service_reset_settings_error.c scr_setup_service_reset_settings_success.c scr_setup_system.c scr_setup_system_date.c scr_setup_system_language.c scr_setup_system_password.c scr_setup_system_time.c scr_status_bar.c
  group app/astek_econ/gui/emwin/touch
    ../../../src/app/astek_econ/gui/emwin/touch/: touch.c
  group app/astek_econ/hw
    ../../../src/app/astek_econ/hw/: external_uart.h hw_cl420.h hw_ltdc.h hw_relay.h internal_uart.h keyboard.h
  group app/astek_econ/hw/hw2331r2
    ../../../src/app/astek_econ/hw/hw2331r2/: hw_config.h stm32f7xx_it.c
  group app/astek_econ/hw/hw2331r2/cl420
    ../../../src/app/astek_econ/hw/hw2331r2/cl420/: hw2331_cl420.c
  group app/astek_econ/hw/hw2331r2/eth
    ../../../src/app/astek_econ/hw/hw2331r2/eth/: hw2331_eth.c hw2331_eth.h webhandlers.c webhandlers.h webpages.h
  group app/astek_econ/hw/hw2331r2/external_flash
    ../../../src/app/astek_econ/hw/hw2331r2/external_flash/: hw2331_ext_flash.c hw2331_ext_flash.h
  group app/astek_econ/hw/hw2331r2/external_uart
    ../../../src/app/astek_econ/hw/hw2331r2/external_uart/: hw2331_external_uart.c
  group app/astek_econ/hw/hw2331r2/internal_uart
    ../../../src/app/astek_econ/hw/hw2331r2/internal_uart/: hw2331_internal_uart.c
  group app/astek_econ/hw/hw2331r2/keyboard
    ../../../src/app/astek_econ/hw/hw2331r2/keyboard/: hw2331_keyboard.c
  group app/astek_econ/hw/hw2331r2/ltdc
    ../../../src/app/astek_econ/hw/hw2331r2/ltdc/: hw2331_ltdc.c
  group app/astek_econ/hw/hw2331r2/relay
    ../../../src/app/astek_econ/hw/hw2331r2/realy/: hw2331_relay.c
  group app/astek_econ/modbus/server
    ../../../src/app/astek_econ/modbus/server/: modbus_server_dev.c
  group app/version
    ../../../src/app/astek_econ/version/: version.c
  group bsp/asback
    ../../../src/bsp/hw2331_rev3/asback/: asback.h asback_cl420.c asback_relay.c
  group bsp/hw2331/beep
    ../../../src/bsp/hw2331_rev3/beep/: beep.c beep.h
  group bsp/hw2331/ext_flash
    ../../../src/bsp/hw2331_rev3/spi_flash/Src/: flash_spi.c
    ../../../src/bsp/hw2331_rev3/spi_flash/Inc/: flash_spi.h
  group bsp/hw2331/gt9xx
    ../../../src/bsp/hw2331_rev3/gt9xx/: gt9xx_x.c
  group bsp/hw2331/stm32
    ../../../src/bsp/hw2331_rev3/stm32/: stm32.h stm32_clock.c stm32_fmc.c stm32_gpio_eth_int.c stm32_gpio_lcd.c stm32_gpio_led1.c stm32_gpio_touch_int.c stm32_i2c1.c stm32_ltdc.c stm32_mpu.c stm32_reset.c stm32_rtc.c stm32_sdram.c stm32_spi2.c stm32_spi4.c stm32_tim2_beep.c stm32_tim4.c stm32_uart4.c stm32_usart1.c stm32_usart2.c
  group bsp/hw2331/w5500
    ../../../src/bsp/hw2331_rev3/w5500/: w5500_work.c w5500_work.h
  group bsp/hw2331/w5500/ioLibrary_Driver/Ethernet
    ../../../src/bsp/hw2331_rev3/w5500/ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
  group bsp/hw2331/w5500/ioLibrary_Driver/Ethernet/w5500
    ../../../src/bsp/hw2331_rev3/w5500/ioLibrary_Driver/Ethernet/W5500/: w5500.c w5500.h
  group bsp/hw2331/w5500/ioLibrary_Driver/Internet/httpServer
    ../../../src/bsp/hw2331_rev3/w5500/ioLibrary_Driver/Internet/httpServer/: httpParser.c httpParser.h httpServer.c httpServer.h httpUtil.c httpUtil.h
  group lib/arm/CMSIS/Device/ST/STM32F7xx/Source
    ../../../src/lib/arm/CMSIS/Device/ST/STM32F7xx/Source/: system_stm32f7xx.c
  group lib/arm/CMSIS/Device/ST/STM32F7xx/Source/iar
    ../../../src/lib/arm/CMSIS/Device/ST/STM32F7xx/Source/iar/: startup_stm32f746xx.s
  group lib/astsoft/econ
    ../../../src/lib/astsoft/econ/: econ.c
  group lib/astsoft/modbus/src
    ../../../src/lib/astsoft/modbus/src/: modbus_crc.c
  group lib/astsoft/modbus/src/rtu
    ../../../src/lib/astsoft/modbus/src/rtu/: modbus_rtu_client.c modbus_rtu_server.c
  group lib/astsoft/modbus/src/tcp
    ../../../src/lib/astsoft/modbus/src/tcp/: modbus_tcp_server.c
  group lib/FreeRTOS
    ../../../src/lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group lib/FreeRTOS/cmsis_rtos
    ../../../src/lib/FreeRTOS/cmsis_rtos/: cmsis_os.c
  group lib/FreeRTOS/portable/IAR/ARM_CM4F
    ../../../src/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib/FreeRTOS/portable/IAR/ARM_CM7/r0p1
    ../../../src/lib/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group lib/FreeRTOS/portable/IAR/ARM_CM7_MPU/r0p1
    ../../../src/lib/FreeRTOS/portable/IAR/ARM_CM7_MPU/r0p1/: port.c portasm.s
  group lib/FreeRTOS/portable/MemMang
    ../../../src/lib/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group lib/FreeRTOS/static
    ../../../src/lib/FreeRTOS/static/: freertos.c vApplicationGetIdleTaskMemory.c vApplicationGetTimerTaskMemory.c vApplicationStackOverflowHook.c
  group lib/goodix/gt9xx
    ../../../src/lib/goodix/gt9xx/: gt9xx.c gt9xx_chksum.c
  group lib/iar/clib
    ../../../src/lib/iar/clib/: time.c
  group lib/st/STemWin/Lib
    ../../../src/lib/st/STemWin/Lib/: STemWin_CM7_OS_wc16.a STemWin_CM7_OS_wc16_ARGB.a STemWin_CM7_OS_wc16_ot.a STemWin_CM7_OS_wc16_ot_ARGB.a STemWin_CM7_OS_wc32.a STemWin_CM7_OS_wc32_ARGB.a STemWin_CM7_OS_wc32_ot.a STemWin_CM7_OS_wc32_ot_ARGB.a STemWin_CM7_wc16.a STemWin_CM7_wc16_ARGB.a STemWin_CM7_wc16_ot.a STemWin_CM7_wc16_ot_ARGB.a STemWin_CM7_wc32.a STemWin_CM7_wc32_ARGB.a STemWin_CM7_wc32_ot.a STemWin_CM7_wc32_ot_ARGB.a
  group lib/st/STemWin/V544/png
    ../../../src/lib/st/STemWin/V544/png/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group lib/st/STM32F7xx_HAL_Driver/Src
    ../../../src/lib/st/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
